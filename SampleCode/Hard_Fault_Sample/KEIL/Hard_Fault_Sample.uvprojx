# Keil uVision project Hard_Fault_Sample.uvprojx, settings and files
target Hard_Fault_Sample (6190000::V6.19::ARMCLANG)
  device: M433SE8AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.23
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x7FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: Hard_Fault_Sample
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG_ENABLE_SEMIHOST
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\Device\Nuvoton\M433\Include;..\..\..\Library\StdDriver\inc
  asm define: DEBUG_ENABLE_SEMIHOST
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --map --first='startup_M433.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M433/Source/: system_M433.c
    ../../../Library/Device/Nuvoton/M433/Source/ARM/: startup_M433.s
  group User
    ../: main.c
  group Library
    ../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c
