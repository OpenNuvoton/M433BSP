# Keil uVision project FreeRTOS.uvprojx, settings and files
target FreeRTOS (6190000::V6.19::ARMCLANG)
  device: M433SE8AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.23
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x7FFFF) CLOCK(84000000) CPUTYPE("Cortex-M4") FPU2
  output: FreeRTOS +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=3
  c define: RVDS_ARMCM4_NUC4xx
  c include: ..\..\..\Library\CMSIS\Include;..\..\..\Library\StdDriver\inc;..\..\..\Library\Device\Nuvoton\M433\Include;..\..\..\ThirdParty\FreeRTOS\Source\include;..\..\..\ThirdParty\FreeRTOS\Demo\COMMON\include;..\..\..\ThirdParty\FreeRTOS\SOURCE\portable\GCC\ARM_CM4F;..\..\FreeRTOS
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group System
    ../../../Library/Device/Nuvoton/M433/Source/: system_M433.c
    ../../../Library/Device/Nuvoton/M433/Source/ARM/: startup_M433.s
  group Demo Files
    ../: main.c ParTest.c
    ../../../ThirdParty/FreeRTOS/Demo/Common/Minimal/: QueueSet.c PollQ.c flash.c
  group FreeRTOS files
    ../../../ThirdParty/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../ThirdParty/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
  group lib
    ../../../Library/StdDriver/src/: retarget.c sys.c uart.c clk.c
