# Keil uVision project MPU.uvproj, settings and files
target MPU (ARM-ADS)
  device: M433SE8AE Nuvoton
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x7FFFF) CLOCK(84000000) CPUTYPE("Cortex-M4") FPU2
  output: MPU
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c include: ..\..\..\..\Library\Device\Nuvoton\M433\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\CMSIS\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --map --first='startup_M433.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M433/Source/: system_M433.c
    ../../../../Library/Device/Nuvoton/M433/Source/ARM/: startup_M433.s
  group Library
    ../../../../Library/StdDriver/src/: clk.c sys.c uart.c retarget.c
  group User
    ../: main.c
