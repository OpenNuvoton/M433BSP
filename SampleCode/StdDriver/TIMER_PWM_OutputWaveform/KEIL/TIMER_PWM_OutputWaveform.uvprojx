# Keil uVision project TIMER_PWM_OutputWaveform.uvprojx, settings and files
target TIMER_PWM_OutputWaveform (6150000::V6.15::ARMCLANG)
  device: M433SE8AE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x9FFF) CLOCK(72000000) CPUTYPE("Cortex-M4") FPU2
  output: TIMER_PWM_OutputWaveform
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M433\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xa000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_M433.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M433/Source/: system_M433.c
    ../../../../Library/Device/Nuvoton/M433/Source/ARM/: startup_M433.s
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c sys.c clk.c uart.c timer_pwm.c
