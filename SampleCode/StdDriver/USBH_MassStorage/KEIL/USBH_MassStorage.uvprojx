# Keil uVision project USBH_MassStorage.uvprojx, settings and files
target HSUSBH_USBH_MassStorage (6190000::V6.19::ARMCLANG)
  device: M433SE8AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.23
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x7FFFF) CLOCK(84000000) CPUTYPE("Cortex-M4") FPU2
  output: HSUSBH_USBH_MassStorage
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\Device\Nuvoton\M433\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\ThirdParty\FatFs\source;..\..\..\..\Library\UsbHostLib\inc
  asm define: Stack_Size=0x800 Heap_Size=0x4000
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --map --first='startup_M433.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M433/Source/: system_M433.c
    ../../../../Library/Device/Nuvoton/M433/Source/ARM/: startup_M433.s
  group User
    ../: main.c diskio.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c
  group UsbHostLib
    ../../../../Library/UsbHostLib/src_core/: usb_core.c hub.c ohci.c mem_alloc.c
  group UsbHostLib_MSC
    ../../../../Library/UsbHostLib/src_msc/: msc_driver.c msc_xfer.c
  group ThirdParty_FatFs
    ../../../../ThirdParty/FatFs/source/: ff.c
