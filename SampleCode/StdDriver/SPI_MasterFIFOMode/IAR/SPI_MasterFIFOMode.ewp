# IAR project SPI_MasterFIFOMode.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M433AE series Nuvoton M433AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\M433\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SPI_MasterFIFOMode.bin
  ILINK.IlinkOutputFile: SPI_MasterFIFOMode.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M433/Source/IAR/: startup_M433.s
    ../../../../Library/Device/Nuvoton/M433/Source/: system_M433.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c gpio.c retarget.c spi.c uart.c
  group User
    ../: main.c
