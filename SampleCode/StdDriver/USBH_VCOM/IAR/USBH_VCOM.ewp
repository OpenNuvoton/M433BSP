# IAR project USBH_VCOM.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M433AE series Nuvoton M433AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\M433\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Library\UsbHostLib\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBH_VCOM.bin
  ILINK.IlinkOutputFile: USBH_VCOM.out
  ILINK.IlinkIcfFile: USBH_VCOM.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M433/Source/IAR/: startup_M433.s
    ../../../../Library/Device/Nuvoton/M433/Source/: system_M433.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c
  group UsbHostLib
    ../../../../Library/UsbHostLib/src_core/: hub.c mem_alloc.c ohci.c usb_core.c
  group UsbHostLib_VCOM
    ../../../../Library/UsbHostLib/src_cdc/: cdc_core.c cdc_driver.c cdc_parser.c
  group User
    ../: main.c
