# IAR project USBH_Firmware_Update.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M433AE series Nuvoton M433AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\M433\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Library\UsbHostLib\inc; ..\..\..\..\ThirdParty\FatFs\source
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: USBH_Firmware_Update.bin
  ILINK.IlinkOutputFile: USBH_Firmware_Update.out
  ILINK.IlinkIcfFile: USBH_Firmware_Update.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M433/Source/IAR/: startup_M433.s
    ../../../../Library/Device/Nuvoton/M433/Source/: system_M433.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c fmc.c retarget.c sys.c uart.c
  group ThirdParty_FatFs
    ../../../../ThirdParty/FatFs/source/: ff.c
  group UsbHostLib
    ../../../../Library/UsbHostLib/src_core/: hub.c mem_alloc.c ohci.c usb_core.c
  group UsbHostLib_MSC
    ../../../../Library/UsbHostLib/src_msc/: msc_driver.c msc_xfer.c
  group User
    ../: diskio.c main.c usbh_update.c
