# Keil uVision project ISP_CAN.uvprojx, settings and files
target ISP_CAN (6190000::V6.19::ARMCLANG)
  device: M433SE8AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.23
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x9FFF) CLOCK(72000000) CPUTYPE("Cortex-M4") FPU2
  output: M433_ISP_CAN
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=7 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M433\Include;..\..\..\..\Library\StdDriver\inc
  memory RVCT4: ROM 0x0 size 0xa000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_M433_isp.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M433/Source/: system_M433.c
    ../../../../Library/Device/Nuvoton/M433/Source/ARM/: startup_M433_isp.s
  group Library
    ../../../../Library/StdDriver/src/: can.c fmc.c clk.c
  group User
    ../: main.c
