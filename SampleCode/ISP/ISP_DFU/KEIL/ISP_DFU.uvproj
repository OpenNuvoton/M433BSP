# Keil uVision project ISP_DFU.uvproj, settings and files
target ISP_DFU (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M433SE8AE Nuvoton
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x7FFFF) CLOCK(84000000) CPUTYPE("Cortex-M4") FPU2
  output: ISP_DFU
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c include: .\;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M433\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --map --first='startup_M433_user.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M433/Source/: system_M433.c
  group User
    ../: descriptors.c main.c fmc_user.c startup_M433_user.s usbd_user.c dfu_transfer.c
